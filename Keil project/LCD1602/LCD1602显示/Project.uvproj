# Keil uVision project Project.uvproj, settings and files
target Target_1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User;.\Driver;.\System
  group User
    ./User/: main.c
  group Driver
    ./Driver/: LCD1602.c LCD1602.h KEY.c KEY.h
  group System
    ./System/: Delay.c Delay.h
