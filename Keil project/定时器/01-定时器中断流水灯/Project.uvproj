# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User;.\Driver;.\System
  group User
    ./User/: main.c
  group Driver
    ./Driver/: LED.c LED.h
  group System
    ./System/: Timer0.c Timer0.h
  group Startup
    ./Startup/: STARTUP.A51
