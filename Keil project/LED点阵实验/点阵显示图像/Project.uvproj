# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RC Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM(0-0xFF) CLOCK(33000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User;.\Driver;.\System
  group User
    ./User/: main.c
  group Driver
    ./Driver/: LEDDZ.c LEDDZ.h
  group System
    ./System/: Delay.c Delay.h
